# Keil uVision project arm_graphic_equalizer_example.uvprojx, settings and files
target SCM402_EVB (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: SCM402F SC
  pack: Keil.SCM4xx_DFP.1.0.3
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x38000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: arm_graphic_equalizer_example
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,ARM_MATH_CM4,SCM402F
  c include: ..\..\..\..\..\SCM4xx_StdPeriph_Driver\inc;..\..\..\..\CM4\CoreSupport;..\..\..\..\CM4\DeviceSupport;..\..\arm_class_marks_example;..\..\..\..\..\..\Project\Templates
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x38000
  group USER
    ./: arm_graphic_equalizer_example_q31.c arm_graphic_equalizer_data.c math_helper.c
  group CMSIS
    ../../../../CM4/DeviceSupport/startup/mdk/: startup_scm402f.s startup_scm403c.s
    ../../../../Lib/ARM/: arm_cortexM4lf_math.lib arm_cortexM4l_math.lib
    ../../../../CM4/DeviceSupport/: system_scm4xx.c
  group SCMPeriph
    ../../../../../SCM4xx_StdPeriph_Driver/src/: scm4xx_rcc.c
  group DOC
    ./: Abstract.txt
target SCM403_EVB (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: SCM403C SC
  pack: Keil.SCM4xx_DFP.1.0.3
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: arm_graphic_equalizer_example
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,ARM_MATH_CM4,SCM403C
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
