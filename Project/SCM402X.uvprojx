# Keil uVision project SCM402X.uvprojx, settings and files
target RT_Thread (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: SCM402FB SC
  pack: Keil.SCM4xx_DFP.1.0.6
  cpu: IRAM(0x20000000,0x100000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RT_Thread +hex
  AfterMake: fromelf.exe  --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: SCM402FB,USE_STDPERIPH_DRIVER,SCM402FB_EVB_V1_0
  c include: ..\Libraries\SCM4xx_StdPeriph_Driver\inc;..\Libraries\Middlewares\SCM_USB-FS-Device_Driver\inc;..\Libraries\CMSIS\CM4\DeviceSupport;..\Libraries\CMSIS\CM4\CoreSupport;..\Libraries\RTOS\rt-thread\include;..\Libraries\RTOS\rt-thread\include\libc;..\Libraries\RTOS\rt-thread\components\finsh;..\Libraries\FileSystem\littlefs-master\src\littlefs-v220\include;..\User\rt_thread;..\User\inc;..\User\main;..\User\littlefs;..\User\bsp\flash
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x100000
  group CMSIS
    ../Libraries/CMSIS/CM4/DeviceSupport/startup/mdk/: startup_scm402fb.s
    ../User/main/: system_scm4xx.c
  group StdPeriph_Driver
    ../Libraries/SCM4xx_StdPeriph_Driver/src/: misc.c scm4xx_gpio.c scm4xx_rcc.c scm4xx_usart.c scm4xx_exti.c scm4xx_acc.c scm4xx_adc.c scm4xx_bkp.c scm4xx_can.c scm4xx_comp.c scm4xx_crc.c scm4xx_dac.c scm4xx_dbgmcu.c scm4xx_dma.c scm4xx_ertc.c scm4xx_flash.c scm4xx_i2c.c scm4xx_iwdg.c scm4xx_pwr.c scm4xx_rtc.c scm4xx_sdio.c scm4xx_spi.c scm4xx_tim.c scm4xx_wwdg.c scm4xx_xmc.c
  group USER/main
    ../User/main/: main.c scm4xx_it.c
  group DOC
    ../Doc/: readme.txt
